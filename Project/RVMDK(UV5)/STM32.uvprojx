# Keil uVision project STM32.uvprojx, settings and files
target CARD (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 wLevel=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,uart1
  c include: ..\..\Libraries\FWlib\inc;..\..\Libraries\CMSIS;..\..\BSP\inc;..\..\USER\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../../USER/src/: main.c frame.c menu.c stm32f10x_it.c
  group BSP
    ../../BSP/src/: bsp_can.c bsp_dac.c bsp_exti.c bsp_font_flash.c bsp_lcd12864.c bsp_led.c bsp_matrix_key.c bsp_usart1.c bsp_delay.c Queue.c bsp_iwdg.c bsp_i2c2.c bsp_general_time.c bsp_stm_flash.c
  group CORE
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group FWLib
    ../../Libraries/FWlib/src/: stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c stm32f10x_dac.c stm32f10x_iwdg.c
